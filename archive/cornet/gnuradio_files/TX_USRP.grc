options:
  parameters:
    author: Cameron Makin
    copyright: Wireless@VT
    description: Implementiation of an USRP TX for SAS control
    generate_options: qt_gui
    id: sas_tx
    output_language: python
    title: SAS USRP Transmitter
  states: {}

blocks:
- name: SDR_A_Address
  id: variable
  parameters:
    value: '"192.168.40.111"'
  states: {}
- name: freq
  id: variable_qtgui_range
  parameters:
    label: USRP Frequency
    orient: Qt.Horizontal
    start: '914000000'
    step: '1000'
    stop: '916000000'
    value: '915000000'
  states: {}
- name: gain
  id: variable_qtgui_range
  parameters:
    label: USRP Gain
    orient: Qt.Horizontal
    start: '0'
    step: '0.5'
    stop: '50'
    value: '0'
  states: {}
- name: samp_rate
  id: variable_qtgui_range
  parameters:
    label: Sample Rate
    orient: Qt.Horizontal
    start: '1000000'
    step: '500000'
    stop: '9000000'
    value: '8000000'
  states: {}
- name: src_amp
  id: variable_qtgui_range
  parameters:
    label: Sig Src Amp
    orient: Qt.Horizontal
    start: '0'
    step: '0.1'
    stop: '10'
    value: '0'
  states: {}
- name: SDR_A
  id: uhd_usrp_sink
  parameters:
    ant0: TX/RX
    bw0: samp_rate
    center_freq0: freq
    dev_addr: '"addr="+SDR_A_Address'
    gain0: gain
    len_tag_name: ''
    norm_gain0: 'False'
    samp_rate: samp_rate
    sync: sync
    type: fc32
  states: {}
- name: analog_noise_source_x_0
  id: analog_noise_source_x
  parameters:
    amp: src_amp
    noise_type: analog.GR_GAUSSIAN
    seed: '0'
    type: complex
  states: {}

connections:
- [analog_noise_source_x_0, '0', SDR_A, '0']

metadata:
  file_format: 1
