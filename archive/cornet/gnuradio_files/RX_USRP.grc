options:
  parameters:
    author: Cameron Makin
    copyright: Wireless@VT
    description: RX Flowgraph for basic USRP RX Applications
    generate_options: qt_gui
    id: sas_rx
    output_language: python
    title: SAS USRP Receiver
  states: {}

blocks:
- name: SDR_Address
  id: variable
  parameters:
    value: '"192.168.40.110"'
  states: {}
- name: bandwidth
  id: variable_qtgui_range
  parameters:
    label: Bandwidth
    min_len: ''
    orient: Qt.Horizontal
    start: '0'
    step: 0.1e6
    stop: 10e6
    value: 10e6
  states: {}
- name: bins
  id: variable
  parameters:
    value: '1024'
  states: {}
- name: freq
  id: variable_qtgui_range
  parameters:
    label: Center Frequency
    min_len: ''
    orient: Qt.Horizontal
    start: 3.55e9
    step: 1e6
    stop: 3.7e9
    value: 3.6e9
  states: {}
- name: gain
  id: variable_qtgui_range
  parameters:
    orient: Qt.Horizontal
    start: '0'
    step: '0.5'
    stop: '31.5'
    value: '0'
  states: {}
- name: blocks_complex_to_mag_squared_0
  id: blocks_complex_to_mag_squared
  parameters:
    vlen: bins
  states: {}
- name: blocks_nlog10_ff_0
  id: blocks_nlog10_ff
  parameters:
    k: '0'
    n: '10'
    vlen: bins
  states: {}
- name: blocks_stream_to_vector_0
  id: blocks_stream_to_vector
  parameters:
    num_items: bins
    type: complex
  states: {}
- name: fft_vxx_0
  id: fft_vxx
  parameters:
    fft_size: bins
    forward: 'True'
    shift: 'True'
    type: complex
    window: window.blackmanharris(bins)
  states: {}
- name: rx_probe
  id: blocks_probe_signal_vx
  parameters:
    type: float
    vlen: bins
  states: {}
- name: uhd_usrp_source_0
  id: uhd_usrp_source
  parameters:
    ant0: RX2
    bw0: bandwidth
    center_freq0: freq
    clock_source0: internal
    dc_offs_enb0: '""'
    dev_addr: '"addr="+SDR_Address'
    dev_args: '""'
    gain0: gain
    iq_imbal_enb0: '""'
    norm_gain0: 'False'
    samp_rate: bandwidth
    sync: sync
    type: fc32
  states: {}

connections:
- [blocks_complex_to_mag_squared_0, '0', blocks_nlog10_ff_0, '0']
- [blocks_nlog10_ff_0, '0', rx_probe, '0']
- [blocks_stream_to_vector_0, '0', fft_vxx_0, '0']
- [fft_vxx_0, '0', blocks_complex_to_mag_squared_0, '0']
- [uhd_usrp_source_0, '0', blocks_stream_to_vector_0, '0']

metadata:
  file_format: 1
